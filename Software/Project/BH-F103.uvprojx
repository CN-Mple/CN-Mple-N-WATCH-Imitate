# Keil uVision project BH-F103.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\bsp_USART;..\User\BUTTON;..\User\MENU;..\User\bsp_OLED;..\User\MY_MENU;..\User\DISPLAY;..\User\ITEM;..\User\bsp_GENERALTIME;..\User\BUZZER;..\User\WATCH;..\User\MPU6050;..\User\ITEM\ITEM2;..\User\MPU6050\eMPL;..\User\ITEM\ITEM1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group HARDWARE
    ../User/bsp_GENERALTIME/: bsp_time.c
    ../User/bsp_USART/: bsp_usart.c
  group eMPL
    ../User/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group mpu6050
    ../User/MPU6050/: bsp_mpu6050.c bsp_SysTick.c
  group BUZZER
    ../User/BUZZER/: BUZZER.C
  group BUTTON
    ../User/BUTTON/: BUTTON.C
  group OLED
    ../User/bsp_OLED/: bsp_oled.c bsp_Font.c
  group DISPLAY
    ../User/DISPLAY/: DISPLAY.C ANIMOTION.C BREATHSCREEN.C
  group MENU
    ../User/MENU/: MENU.C
  group WATCH
    ../User/WATCH/: WATCH.C bsp_power.c DS3231.C
  group MY_MENU
    ../User/MY_MENU/: MY_MENU.C
  group APP_ITEM
    ../User/ITEM/: ITEM1.C ITEM2.C ITEM3.C ITEM4.C ITEM5.C
  group ITEM1
    ../User/ITEM/ITEM1/: ITEM_TIMESET.C ITEM_LIGHT.C ITEM_SOUND.C
  group ITEM2
    ../User/ITEM/ITEM2/: GAME1.C GAME2.C
